<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Port_Driver.ewp</path>
    </project>
    <batchBuild />
</workspace>
